

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SYS_TOP 
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 1.745 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.39345 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.377 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6258 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.575 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.0082 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 11.397 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 55.012 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 8.131 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 39.3025 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 492.396 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 2384.68 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 4.74109 LAYER VIA67 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 3.735 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.9654 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 20.499 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 98.7926 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 513.408 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2483.28 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.74109 LAYER VIA56 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 1.973 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.49013 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.377 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6258 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 7.885 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 38.1193 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 12.946 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 62.4627 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 259.731 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1263.09 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.74109 LAYER VIA56 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 3.235 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.5604 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.072 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1587 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 76.4287 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 374.19 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END SI[0]
  PIN SO[3] 
    ANTENNAPARTIALMETALAREA 3.745 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.0135 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.537 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 12.395 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 59.8124 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1872 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 130.887 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 633.656 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.99712 LAYER VIA56 ;
  END SO[3]
  PIN SO[2] 
    ANTENNAPARTIALMETALAREA 3.025 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.5503 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 10.076 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 48.658 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.537 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 28.507 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 137.503 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4108 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 84.7864 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 411.499 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.05453 LAYER VIA56 ;
  END SO[2]
  PIN SO[1] 
    ANTENNAPARTIALMETALAREA 1.719 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.26839 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 14.372 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 69.3217 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0871 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 183.38 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 887.681 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 2.90126 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL5 ;
    ANTENNAGATEAREA 0.0871 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 186.457 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 904.69 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAMAXCUTCAR 3.7302 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 0.6038 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.09235 LAYER METAL6 ;
    ANTENNAGATEAREA 0.0871 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 193.389 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 928.712 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNAMAXCUTCAR 6.70609 LAYER VIA67 ;
    ANTENNADIFFAREA 0.537 LAYER METAL7 ; 
    ANTENNAPARTIALMETALAREA 71.18 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 417.339 LAYER METAL7 ;
    ANTENNAGATEAREA 0.0871 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 1010.61 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 5720.2 LAYER METAL7 ;
  END SO[1]
  PIN SO[0] 
    ANTENNAPARTIALMETALAREA 1.735 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.34535 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 21.834 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 105.214 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 0.6038 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.09235 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNADIFFAREA 0.6 LAYER METAL7 ; 
    ANTENNAPARTIALMETALAREA 40.608 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 238.493 LAYER METAL7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2002 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 305.066 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 1681.23 LAYER METAL7 ;
  END SO[0]
  PIN RST_N 
    ANTENNAPARTIALMETALAREA 0.519 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.49639 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 2.131 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4425 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 11.912 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 57.4891 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 240.206 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 1169.98 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 6.09568 LAYER VIA67 ;
  END RST_N
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.241 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.15921 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 7.192 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.7859 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 3.42 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6426 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1.42961 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 7.02216 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.455 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.18855 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.19 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7263 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.796 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.02116 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.442275 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 2.27309 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END REF_CLK
  PIN UART_RX_IN 
    ANTENNAPARTIALMETALAREA 3.293 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.8393 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 9.953 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 48.0663 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 53.5097 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 258.346 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.703018 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.698 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.35978 LAYER METAL4 ;
    ANTENNAGATEAREA 0.3809 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 57.9676 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 280.294 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.74843 LAYER VIA45 ;
  END UART_RX_IN
  PIN SE 
    ANTENNAPARTIALMETALAREA 1.631 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.84511 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 11.2268 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 52.1474 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.411396 LAYER VIA23 ;
  END SE
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 4.715 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.6792 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.432 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.27032 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0871 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 9.32721 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 48.2776 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.2434 LAYER VIA34 ;
  END test_mode
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.255 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.22655 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 6.7 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.4194 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 2.32258 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 11.2545 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 1.517 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.29677 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 8.904 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 43.213 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1066 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 115.328 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 558.483 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 8.386 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.5291 LAYER METAL4 ;
    ANTENNAGATEAREA 0.1599 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 167.774 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 811.948 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END scan_rst
  PIN UART_TX_O 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 3.877 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.6484 LAYER METAL3 ;
  END UART_TX_O
  PIN parity_error 
    ANTENNAPARTIALMETALAREA 6.556 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.5344 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.782 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.8138 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 6.254 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 30.2741 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 0.7678 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.88119 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNADIFFAREA 0.401 LAYER METAL7 ; 
    ANTENNAPARTIALMETALAREA 49.792 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 292.219 LAYER METAL7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 283.81 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 1620.24 LAYER METAL7 ;
  END parity_error
  PIN framing_error 
    ANTENNAPARTIALMETALAREA 11.74 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.4694 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.401 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 9.232 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 44.7907 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2925 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 56.8805 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 276.947 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.952351 LAYER VIA45 ;
  END framing_error
END SYS_TOP

END LIBRARY
